# Keil uVision project motor.uvprojx, settings and files
target qitas (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: motor +hex
  AfterMake: fromelf.exe --bin -o./motor.bin ./obj/motor.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libs\CMSIS\CM3\CoreSupport;..\Libs\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libs\STM32F10x_StdPeriph_Driver\inc;..\user;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c stm32f10x_it.c
    ../Libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group BSP
    ../BSP/: bsp_key.c bsp_debug_usart.c bsp_TB6600_TIM.c
  group Libs
    ../Libs/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_usart.c
  group CMSIS
    ../Libs/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
